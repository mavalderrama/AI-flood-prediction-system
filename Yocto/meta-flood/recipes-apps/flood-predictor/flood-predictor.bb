SUMMARY = "Daily Mississippi River flood forecaster on the topann FPGA accelerator"
DESCRIPTION = "Reads daily gauge readings, computes the model features and runs \
the topann MLP on the PL through UIO. Installs the bitstreams for the Linux \
FPGA Manager and the module options that bind uio_pdrv_genirq to the IP."
LICENSE = "CLOSED"

# Bitstream variants (Vivado/build_hw.tcl) installed in /lib/firmware/topann.
# Example in local.conf: TOPANN_VARIANTS = "WO-OPT PIPELINE FULL-PIPE"
TOPANN_VARIANTS ?= "WO-OPT"

# Sources come straight from this repository (FLOOD_REPO_DIR, conf/layer.conf).
# Zynq7K/Software/xtopann_hw.h must be the one generated by Vivado/HLS/run_hls.tcl;
# the build stops with an explicit #error otherwise.
FILESEXTRAPATHS:prepend := "${FLOOD_REPO_DIR}:"
SRC_URI = " \
    file://Zynq7K/Software/makefile \
    file://Zynq7K/Software/ANN.cpp \
    file://Zynq7K/Software/ANN.h \
    file://Zynq7K/Software/ann_ref.cpp \
    file://Zynq7K/Software/ann_ref.h \
    file://Zynq7K/Software/ann_regs.h \
    file://Zynq7K/Software/features.cpp \
    file://Zynq7K/Software/features.h \
    file://Zynq7K/Software/predictor.cpp \
    file://Zynq7K/Software/xtopann_hw.h \
    file://Vivado/HLS/model_params.h \
    file://Vivado/HLS/tanh_lut.h \
    file://Zynq7K/script/fpga.sh \
    file://data/processed/golden_replay.csv \
    ${@' '.join('file://Zynq7K/bitstreams/topann-%s.bit.bin' % v for v in d.getVar('TOPANN_VARIANTS').split())} \
"
S = "${UNPACKDIR}"

# The module is built by the kernel fragment in recipes-kernel/linux.
RRECOMMENDS:${PN} = "kernel-module-uio-pdrv-genirq"

do_compile() {
    oe_runmake -C ${S}/Zynq7K/Software arm \
        TARGET_CXX="${CXX}" TARGET_CXXFLAGS="${CXXFLAGS}" TARGET_LDFLAGS="${LDFLAGS}" \
        PREDICTOR_OUT=${B}/flood-predictor
}

do_install() {
    install -d ${D}${bindir}
    install -m 0755 ${B}/flood-predictor ${D}${bindir}/flood-predictor
    install -m 0755 ${S}/Zynq7K/script/fpga.sh ${D}${bindir}/topann-load

    install -d ${D}${datadir}/flood-predictor
    install -m 0644 ${S}/data/processed/golden_replay.csv ${D}${datadir}/flood-predictor/

    install -d ${D}${nonarch_base_libdir}/firmware/topann
    for v in ${TOPANN_VARIANTS}; do
        install -m 0644 ${S}/Zynq7K/bitstreams/topann-$v.bit.bin ${D}${nonarch_base_libdir}/firmware/topann/
    done

    # Bind uio_pdrv_genirq to the "generic-uio" node of Yocto/dts/topann-user.dtsi
    # without depending on kernel bootargs.
    install -d ${D}${sysconfdir}/modprobe.d ${D}${sysconfdir}/modules-load.d
    echo "options uio_pdrv_genirq of_id=generic-uio" > ${D}${sysconfdir}/modprobe.d/topann-uio.conf
    echo "uio_pdrv_genirq" > ${D}${sysconfdir}/modules-load.d/topann-uio.conf
}

FILES:${PN} += "${nonarch_base_libdir}/firmware/topann"
